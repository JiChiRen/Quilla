# Keil uVision project QAPP.uvprojx, settings and files
target QAPP (6160000::V6.16::ARMCLANG)
  device: GD32F502VE GigaDevice
  pack: GigaDevice.GD32F50x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") DSP CLOCK(12000000) ELITTLE
  output: QAPP +hex
  AfterMake: fromelf --bincombined --output=.\Output\QAPP.bin .\Output\QAPP.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c define: GD32F50X,GD32F502,QAPP_BUILD,QUILLA_QBOOT_APP_START=0x08007000U,QUILLA_QBOOT_FLAG_ADDR=0x08006000U,QUILLA_QBOOT_PAGE_SIZE=2048U,QUILLA_QBOOT_RAM_START=0x20000000U,QUILLA_QBOOT_RAM_SIZE=0x00010000U
  c include: ..;..\Inc;..\..\..\os;..\..\..\os\sys;..\..\..\os\lib;..\..\..\os\services\shell;..\..\..\os\services\quilla-qboot;..\..\..\arch\cpu\arm;..\..\..\arch\cpu\arm\gd32f502ve;..\..\..\arch\platform\arm;..\..\..\arch\platform\arm\gd32f502ve;..\..\..\arch\cpu\arm\CMSIS\Core\Include;..\..\..\arch\cpu\arm\CMSIS\Device\GigaDevice\GD32F50x\Include;..\..\..\arch\cpu\arm\vendor\GigaDevice\GD32F50x_Firmware_Library\GD32F50x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x79000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --remove
  group Startup
    ../../../arch/cpu/arm/CMSIS/Device/GigaDevice/GD32F50x/Source/ARM/: startup_gd32f50x.s
  group GD32F50x_Peripherals
    ../../../arch/cpu/arm/vendor/GigaDevice/GD32F50x_Firmware_Library/GD32F50x_standard_peripheral/Source/: gd32f50x_rcu.c gd32f50x_gpio.c gd32f50x_usart.c gd32f50x_dma.c gd32f50x_timer.c gd32f50x_fmc.c gd32f50x_misc.c gd32f50x_syscfg.c gd32f50x_pmu.c gd32f50x_rtc.c gd32f50x_fwdgt.c
  group Application/User
    ../Src/: main.c
  group os/sys
    ../../../os/sys/: atomic.c autostart.c ctimer.c etimer.c mutex.c process.c kern-guard.c kern-nomalloc.c kern-stack.c kern-flow.c process-mutex.c rtimer.c stimer.c timer.c
  group os/lib
    ../../../os/lib/: assert.c crc16.c list.c memb.c ringbuf.c ringbufindex.c
  group os/services
    ../../../os/services/shell/: quilla-shell.c
  group quilla-qboot
    ../../../os/services/quilla-qboot/: quilla-qboot-flag.c quilla-qboot-meta.c quilla-app-qboot.c
  group mounter
    ../../../arch/cpu/arm/gd32f502ve/: clock.c rtimer-arch.c lpm.c soc.c shellport.c quilla-qboot-hal.c
    ../../../arch/cpu/arm/gd32f502ve/dev/: watchdog.c qwdt.c qclk.c
    ../../../arch/cpu/arm/: int-master.c
    ../../../arch/platform/arm/gd32f502ve/: platform.c
  group CMSIS/Device
    ../../../arch/cpu/arm/CMSIS/Device/GigaDevice/GD32F50x/Source/: system_gd32f50x.c
software components: CMSIS:CORE 6.1.1
