# Keil uVision project QBOOT.uvprojx, settings and files
target QBOOT_CHECK (6160000::V6.16::ARMCLANG)
  device: GD32F502VE GigaDevice
  pack: GigaDevice.GD32F50x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") DSP CLOCK(12000000) ELITTLE
  output: QBOOT_CHECK +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c define: GD32F50X,GD32F502,QBOOT_BUILD,QUILLA_QBOOT_APP_START=0x08007000U,QUILLA_QBOOT_FLAG_ADDR=0x08006000U,QUILLA_QBOOT_PAGE_SIZE=2048U,QUILLA_QBOOT_RAM_START=0x20000000U,QUILLA_QBOOT_RAM_SIZE=0x00010000U,QUILLA_SB_BOOT_MODE=QUILLA_SB_BOOT_MODE_CHECK,QUILLA_QBOOT_VARIANT_STR=\"CHECK\"
  c include: ..;..\Inc;..\..\..\os;..\..\..\os\sys;..\..\..\os\lib;..\..\..\os\services\shell;..\..\..\os\services\quilla-qboot;..\..\..\arch\cpu\arm;..\..\..\arch\cpu\arm\gd32f502ve;..\..\..\arch\platform\arm;..\..\..\arch\platform\arm\gd32f502ve;..\..\..\arch\cpu\arm\CMSIS\Core\Include;..\..\..\arch\cpu\arm\CMSIS\Device\GigaDevice\GD32F50x\Include;..\..\..\arch\cpu\arm\vendor\GigaDevice\GD32F50x_Firmware_Library\GD32F50x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --remove
  group Startup
    ../../../arch/cpu/arm/CMSIS/Device/GigaDevice/GD32F50x/Source/ARM/: startup_gd32f50x.s
  group GD32F50x_Peripherals
    ../../../arch/cpu/arm/vendor/GigaDevice/GD32F50x_Firmware_Library/GD32F50x_standard_peripheral/Source/: gd32f50x_rcu.c gd32f50x_gpio.c gd32f50x_usart.c gd32f50x_dma.c gd32f50x_fmc.c gd32f50x_misc.c gd32f50x_syscfg.c
  group os/sys
    ../../../os/sys/: process.c kern-guard.c kern-nomalloc.c kern-stack.c kern-flow.c etimer.c timer.c atomic.c
  group os/lib
    ../../../os/lib/: sha256.c sha512.c crc16.c list.c memb.c ringbuf.c ringbufindex.c assert.c
  group os/services
    ../../../os/services/shell/: quilla-shell.c
  group quilla-qboot
    ../../../os/services/quilla-qboot/: quilla-qiap.c quilla-qboot-flag.c quilla-qboot-meta.c quilla-ed25519.c quilla-qboot-secure.c
  group mounter
    ../../../arch/cpu/arm/gd32f502ve/: clock.c shellport.c qboot-main.c quilla-qboot-hal.c
    ../../../arch/cpu/arm/: int-master.c
  group CMSIS/Device
    ../../../arch/cpu/arm/CMSIS/Device/GigaDevice/GD32F50x/Source/: system_gd32f50x.c
target QBOOT_SEALED (6160000::V6.16::ARMCLANG)
  device: GD32F502VE GigaDevice
  pack: GigaDevice.GD32F50x_DFP.1.0.1
  cpu: as above
  output: QBOOT_SEALED +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: GD32F50X,GD32F502,QBOOT_BUILD,QUILLA_QBOOT_APP_START=0x08007000U,QUILLA_QBOOT_FLAG_ADDR=0x08006000U,QUILLA_QBOOT_PAGE_SIZE=2048U,QUILLA_QBOOT_RAM_START=0x20000000U,QUILLA_QBOOT_RAM_SIZE=0x00010000U,QUILLA_QBOOT_DEFAULT_KEY,QUILLA_SB_BOOT_MODE=QUILLA_SB_BOOT_MODE_SEALED,QUILLA_QBOOT_VARIANT_STR=\"SEALED\"
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --remove
target QBOOT_SEC (6160000::V6.16::ARMCLANG)
  device: GD32F502VE GigaDevice
  pack: GigaDevice.GD32F50x_DFP.1.0.1
  cpu: as above
  output: QBOOT_SEC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: GD32F50X,GD32F502,QBOOT_BUILD,QUILLA_QBOOT_DEFAULT_KEY,QUILLA_QBOOT_APP_START=0x08007000U,QUILLA_QBOOT_FLAG_ADDR=0x08006000U,QUILLA_QBOOT_PAGE_SIZE=2048U,QUILLA_QBOOT_RAM_START=0x20000000U,QUILLA_QBOOT_RAM_SIZE=0x00010000U,QUILLA_PRODUCTION_BUILD,QUILLA_SB_BOOT_MODE=QUILLA_SB_BOOT_MODE_SECURE,QUILLA_QBOOT_VARIANT_STR=\"SEC\"
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --remove
