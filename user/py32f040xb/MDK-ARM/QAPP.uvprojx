# Keil uVision project QAPP.uvprojx, settings and files
target QAPP (6160000::V6.16::ARMCLANG)
  device: PY32F040xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: QAPP +hex
  AfterMake: fromelf --bincombined --output=.\Output\QAPP.bin .\Output\QAPP.axf
  c flags: Optim=2 OneElfS=1 uC99=2 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,PY32F040xB,QAPP_BUILD,QUILLA_QBOOT_APP_START=0x08007000U,QUILLA_QBOOT_FLAG_ADDR=0x08006000U
  c include: .;..\..\..\os\;..\..\..\os\sys;..\..\..\os\lib;..\..\..\os\services;..\..\..\os\net;..\..\..\os\net\mac;..\..\..\arch\cpu\arm;..\..\..\arch\cpu\arm\py32f040xb;..\..\..\arch\cpu\arm\CMSIS\Core\Include;..\..\..\arch\platform\arm;..\..\..\arch\platform\arm\py32f040xb;..\src;..\Inc;..\BSP\py32f040xx_Start_Kit;..\..\..\arch\cpu\arm\CMSIS\Device\Puya\PY32F040\Include;..\..\..\arch\cpu\arm\vendor\Puya\PY32F040_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x19000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --remove
  group os/sys
    ../../../os/sys/: atomic.c autostart.c ctimer.c etimer.c mutex.c process.c kern-guard.c kern-nomalloc.c kern-stack.c kern-flow.c process-mutex.c rtimer.c stimer.c timer.c
  group os/lib
    ../../../os/lib/: assert.c crc16.c list.c memb.c ringbuf.c ringbufindex.c
  group mounter
    ../../../arch/cpu/arm/py32f040xb/: rtimer-arch.c clock.c lpm.c soc.c shellport.c quilla-qboot-hal.c
    ../../../arch/cpu/arm/: int-master.c dbg.c
    ../../../arch/platform/arm/py32f040xb/: platform.c
    ../../../arch/cpu/arm/py32f040xb/dev/: watchdog.c qwdt.c qclk.c
    ../../../os/services/shell/: quilla-shell.c
  group CMSIS/PY32F040_HAL_Driver
    ../../../arch/cpu/arm/vendor/Puya/PY32F040_HAL_Driver/Src/: py32f040_hal.c py32f040_hal_rcc.c py32f040_hal_rcc_ex.c py32f040_hal_gpio.c py32f040_hal_dma.c py32f040_hal_pwr.c py32f040_hal_uart.c py32f040_hal_cortex.c py32f040_hal_lptim.c py32f040_hal_iwdg.c py32f040_hal_flash.c
  group CMSIS/MSP
    ../../../arch/cpu/arm/CMSIS/Device/Puya/PY32F040/Source/ARM/: startup_py32f040xx.s
    ../../../arch/cpu/arm/CMSIS/Device/Puya/PY32F040/Source/: system_py32f040.c
  group Application/User
    ../Src/: main.c py32f040_hal_msp.c py32f040_it.c
  group Doc
    ../: readme.txt
  group quilla-qboot
    ../../../os/services/quilla-qboot/: quilla-qboot-flag.c quilla-qboot-meta.c quilla-app-qboot.c
software components: CMSIS:CORE 6.1.1
