# Keil uVision project QBOOT.uvprojx, settings and files
target QBOOT_CHECK (6160000::V6.16::ARMCLANG)
  device: PY32F040xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00006000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: QBOOT_CHECK +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,PY32F040xB,QBOOT_BUILD,QUILLA_QBOOT_APP_START=0x08007000U,QUILLA_QBOOT_FLAG_ADDR=0x08006000U,QUILLA_SB_BOOT_MODE=QUILLA_SB_BOOT_MODE_CHECK,QUILLA_QBOOT_VARIANT_STR=\"CHECK\"
  c include: .;..\..\..\os\;..\..\..\os\sys;..\..\..\os\lib;..\..\..\os\services;..\..\..\os\net;..\..\..\os\net\mac;..\..\..\arch\cpu\arm;..\..\..\arch\cpu\arm\py32f040xb;..\..\..\arch\cpu\arm\CMSIS\Core\Include;..\..\..\arch\platform\arm;..\..\..\arch\platform\arm\py32f040xb;..\src;..\Inc;..\BSP\py32f040xx_Start_Kit;..\..\..\arch\cpu\arm\CMSIS\Device\Puya\PY32F040\Include;..\..\..\arch\cpu\arm\vendor\Puya\PY32F040_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS/MSP
    ../../../arch/cpu/arm/CMSIS/Device/Puya/PY32F040/Source/ARM/: startup_py32f040xx.s
    ../../../arch/cpu/arm/CMSIS/Device/Puya/PY32F040/Source/: system_py32f040.c
  group CMSIS/PY32F040_HAL_Driver
    ../../../arch/cpu/arm/vendor/Puya/PY32F040_HAL_Driver/Src/: py32f040_hal.c py32f040_hal_cortex.c py32f040_hal_dma.c py32f040_hal_flash.c py32f040_hal_gpio.c py32f040_hal_pwr.c py32f040_hal_rcc.c py32f040_hal_rcc_ex.c py32f040_hal_uart.c
  group os/sys
    ../../../os/sys/: atomic.c process.c kern-guard.c kern-nomalloc.c kern-stack.c kern-flow.c etimer.c timer.c
  group os/lib
    ../../../os/lib/: assert.c crc16.c list.c memb.c ringbuf.c ringbufindex.c sha256.c sha512.c
  group os/services
    ../../../os/services/shell/: quilla-shell.c
  group mounter
    ../../../arch/cpu/arm/py32f040xb/: shellport.c clock.c quilla-qboot-hal.c qboot-main.c
    ../../../arch/cpu/arm/: int-master.c
  group quilla-qboot
    ../../../os/services/quilla-qboot/: quilla-qboot-flag.c quilla-qboot-meta.c quilla-qiap.c quilla-ed25519.c quilla-qboot-secure.c
target QBOOT_SEALED (6160000::V6.16::ARMCLANG)
  device: PY32F040xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: as above
  output: QBOOT_SEALED +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,PY32F040xB,QBOOT_BUILD,QUILLA_QBOOT_DEFAULT_KEY,QUILLA_SB_BOOT_MODE=QUILLA_SB_BOOT_MODE_SEALED,QUILLA_QBOOT_APP_START=0x08007000U,QUILLA_QBOOT_FLAG_ADDR=0x08006000U,QUILLA_QBOOT_VARIANT_STR=\"SEALED\"
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
target QBOOT_SEC (6160000::V6.16::ARMCLANG)
  device: PY32F040xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: as above
  output: QBOOT_SEC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,PY32F040xB,QBOOT_BUILD,QUILLA_QBOOT_DEFAULT_KEY,QUILLA_PRODUCTION_BUILD,QUILLA_SB_BOOT_MODE=QUILLA_SB_BOOT_MODE_SECURE,QUILLA_QBOOT_APP_START=0x08007000U,QUILLA_QBOOT_FLAG_ADDR=0x08006000U,QUILLA_QBOOT_VARIANT_STR=\"SEC\"
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 6.1.1
